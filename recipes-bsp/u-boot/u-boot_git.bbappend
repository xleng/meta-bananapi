SRC_URI = "git://github.com/LeMaker/u-boot-bananapi.git;protocol=git;branch=bananapi"

PV = "v2014.07"
SRCREV = "10b3537be1b76f49be8e4ae1289411b24d4e72e6"

