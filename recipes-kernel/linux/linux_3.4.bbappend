SRCREV_pn-${PN} = "a48690dd2d0a4f9b88541f4b169fa8b754d45853"

SRC_URI = "git://github.com/LeMaker/linux-bananapi.git;protocol=git;branch=bananapi-3.4 \
        file://defconfig \
        "
